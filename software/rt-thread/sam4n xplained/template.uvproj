# Keil uVision project template.uvproj, settings and files
target RT-Thread SAM4N (ARM-ADS)
  device: SAM4N16C Atmel
  cpu: IRAM(0x20000000-0x20013FFF) IROM(0x400000-0x4FFFFF) CLOCK(12000000) CPUTYPE("Cortex-M4")
  output: rtthread-sam4n
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x400000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x14000
