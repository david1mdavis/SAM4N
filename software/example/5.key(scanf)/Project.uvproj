# Keil uVision project Project.uvproj, settings and files
target Project (ARM-ADS)
  device: SAM4N16C Atmel
  cpu: IRAM(0x20000000-0x20013FFF) IROM(0x400000-0x4FFFFF) CLOCK(12000000) CPUTYPE("Cortex-M4")
  output: Project
  c flags: Optim=1
  c define: __SAM4N16C__
  c include: .\Applications;.\CMSIS\include;.\Drivers
  library: MicroLIB
  memory RVCT4: ROM 0x400000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x14000
  group Applications
    ./Applications/: main.c
  group CMSIS
    ./CMSIS/source/: system_SAM4N.c startup_SAM4N.s
  group Drivers
    ./Drivers/: drv_led.c delay.c drv_usart.c drv_uart.c drv_key.c
